Commit message: modifi candycontrol fix rule. add sp_ball urdf

File: models/ball_sp.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link ball: geometry collision sphere radius=0.07; visual sphere radius=0.07
